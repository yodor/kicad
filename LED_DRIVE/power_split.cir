* /home/yodor/kicad/LED_DRIVE/power_split.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Sun 10 Jan 2016 01:57:15 PM EET

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  /12V /12V CONN_2
R4  /12V Net-_Q1-Pad1_ 10K
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ GND BC547
R2  /12V_EN Net-_Q1-Pad2_ 1K
C6  Net-_C6-Pad1_ GND 4.7uF
R3  /5V Net-_C6-Pad1_ 100R
C1  /5V GND 470uF
IR_SENSOR1  /IR ? Net-_C6-Pad1_ GND CONN_4
R5  /5V Net-_D2-Pad1_ 680R
C5  /5V GND 100nF
D2  Net-_D2-Pad1_ GND LED
FB2  /5V Net-_C4-Pad2_ FILTER
FB1  /5V Net-_C2-Pad1_ FILTER
C2  Net-_C2-Pad1_ GND 100nF
J1  /5V ? ? ? ? ? Net-_C2-Pad1_ GND ? ? /12V_EN ? ? /IR ? /LED_RGB ? ? ? Net-_C4-Pad2_ Net-_C4-Pad2_ GND ? ? ? /TEMP_IN Net-_FB5-Pad1_ Net-_FB4-Pad1_ ATMEGA328P
C4  GND Net-_C4-Pad2_ 100nF
Reg12/5  /12V GND GND /5V CONN_4
Q2  /12V_SW Net-_Q1-Pad1_ /12V IRF4905
U1  /12V_SW /12V_SW CONN_2
U3  GND GND CONN_2
P2  /5V GND ? /TEMP_IN CONN_4
P1  /5V GND ? /LED_RGB CONN_4
U4  GND GND CONN_2
C3  /5V GND 1000uF
S1  /SEG_E /SEG_D /SEG_DP /SEG_C /SEG_G /SEG_B /D3 /D2 /SEG_F /SEG_A /D1 7SEGM_COMMON_ANODE
J2  /EN_D2 /EN_D1 /SEG_B ? ? /SEG_F /SEG_A ? Net-_C7-Pad1_ GND ? /SCL /SDA ? GND GND GND Net-_J2-Pad18_ ? ? /SEG_E /SEG_D /SEG_DP /SEG_C /SEG_G ? ? /EN_D3 MCP23017
Q3  /5V Net-_Q3-Pad2_ /D1 BC547
Q4  /5V Net-_Q4-Pad2_ /D2 BC547
Q5  /5V Net-_Q5-Pad2_ /D3 BC547
R1  /EN_D1 Net-_Q3-Pad2_ 33K
R6  /EN_D2 Net-_Q4-Pad2_ 33K
R7  /EN_D3 Net-_Q5-Pad2_ 33K
C7  Net-_C7-Pad1_ GND 100nF
R8  Net-_J2-Pad18_ /5V 10K
P3  GND /SDA /SCL GND CONN_4
FB3  Net-_C7-Pad1_ /5V FILTER
P4  /5V GND CONN_2
C8  /5V GND 47uF
FB4  Net-_FB4-Pad1_ /SCL FILTER
FB5  Net-_FB5-Pad1_ /SDA FILTER
P5  GND /SDA /SCL GND CONN_4
P6  /5V GND CONN_2

.end
